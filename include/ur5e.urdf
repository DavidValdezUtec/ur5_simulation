Commit message: Update ur5e.urdf

File: include/ur5e.urdf (robot description, URDF)
Before this commit: robot ur5e, 13 links, 12 joints
Joints:
- joint wrist_3_link-ft_frame: origin xyz=0 0 0 rpy=3.141592653589793 0 0 -> xyz=0 0 0.5 rpy=3.141592653589793 0 0
